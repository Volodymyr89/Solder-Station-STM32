# Keil uVision project SOLDER_STATION_STM32_r0015_05042022.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SOLDER_STATION_STM32_r0015_05042022
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main_SOLDER_STATION_STM32.c STM32_GPIO_Lib.c SSD1306.h Short_Delays_us_ms.c SPI_Transmitt.c Solder_Station_STM32.c Interrupts.c
  group Header Group 1
    ./: STM32_GPIO_lib.h SDD1306.c Short_Delays_us_ms.h SPI_Transmitt.h Solder_Station_STM32.h interrupts.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
